V1 Net1 0 SINE ( 0 10 0.159Khz 0.0S 0 )
 R1 NET2 Net1 10
 L1 NET1 0 10MH
 C1 NET2 0 2NF
 C2 NET2 0 3NF
 C3 NET2 0 5NF
 C4 NET2 0 10NF
 C5 NET2 0 2NF
 C6 NET2 0 3NF
 C7 NET2 0 5NF
 C8 NET2 0 10NF
x
