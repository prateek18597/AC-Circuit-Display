R1 NET2 NET3 2200
C1 NET3 0 1F
V1 NET2 NET1 SINE ( 0.0 5 60Khz 0.0S 0 )
V2 NET1 0 SINE ( 0.0 5 90Khz 0.0S 0 )
