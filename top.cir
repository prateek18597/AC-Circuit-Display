R1 NET2 NET3 22K
C1 NET3 0 1UF
V1 NET2 NET1 SINE ( 0.0 5 6hz 0.0S 0 )
V2 NET1 0 SINE ( 0.0 5 1hz 0.0S 0 )
