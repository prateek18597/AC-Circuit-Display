R1 NET2 NET3 22K
C1 NET3 0 1UF
R2 NET4 NET3 22K
C2 NET4 NET5 1UF
R3 NET5 NET6 22K
C4 NET5 NET6 1UF
R4 NET4 NET6 22K
C3 NET7 0 1UF
R5 NET8 NET1 22K
C5 NET8 0 1UF
R6 NET7 NET3 22K
C6 NET5 0 1UF
V1 NET2 NET1 SINE ( 0.0 5 60hz 0.0S 0 )
V2 NET1 0 SINE ( 0.0 5 90hz 0.0S 0 )
